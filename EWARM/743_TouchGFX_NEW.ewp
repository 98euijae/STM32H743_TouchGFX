# IAR project 743_TouchGFX_NEW.ewp, settings and files
configuration 743_TouchGFX_NEW (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../Core/Inc; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/videos/include; ../TouchGFX/gui/include; ../Drivers/BSP; ../Drivers/BSP/Components; ../Drivers/BSP/Components/Common; ../Drivers/BSP/Components/exc7200; ../Drivers/BSP/Components/mfxstm32l152; ../Drivers/BSP/Components/ts3510; ../Middlewares/Third_Party/FatFs/src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: 743_TouchGFX_NEW.hex
  ILINK.IlinkOutputFile: 743_TouchGFX_NEW.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 743_TouchGFX_NEW.ipcf
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Drivers
    ../Core/Src/: sd_diskio.c
  group Drivers/BSP
    ../Drivers/BSP/: stm32h743i_eval_bus.c stm32h743i_eval_io.c stm32h743i_eval_sd.c stm32h743i_eval_ts.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
    ../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_consola_15_4bpp_0.cpp Font_consola_20_4bpp_0.cpp Font_consolab_15_4bpp_0.cpp Font_SCDream6_otf_15_4bpp_0.cpp Font_SCDream6_otf_15_4bpp_21.cpp Font_SCDream6_otf_15_4bpp_24.cpp Font_SCDream6_otf_15_4bpp_25.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_consola_15_4bpp.cpp Kerning_consola_20_4bpp.cpp Kerning_consolab_15_4bpp.cpp Kerning_SCDream6_otf_15_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_consola_15_4bpp.cpp Table_consola_20_4bpp.cpp Table_consolab_15_4bpp.cpp Table_SCDream6_otf_15_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp UnmappedDataFont.cpp
  group TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/containers/: Graph1Base.cpp
    ../TouchGFX/generated/gui_generated/src/graph_screen/: GraphViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp SVGDatabase.cpp
    ../TouchGFX/generated/images/src/__generated/: image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_normal.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_pressed.cpp
  group TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: Graph1.cpp
  group TouchGFX/gui/graph_screen
    ../TouchGFX/gui/src/graph_screen/: GraphPresenter.cpp GraphView.cpp
  group TouchGFX/gui/main_screen
    ../TouchGFX/gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core.a
