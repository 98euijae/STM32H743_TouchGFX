<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\743_TouchGFX_NEW.ewp</path>
  </project>
  <batchBuild />
</workspace>
